Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-06T23:17:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 06 23:17:50 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{65D281DA-BD6E-46A0-9EC2-120886CE5584}\ifc * Database version: 5507 * Database creation date: Mon Aug 06 23:17:49 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 06 23:17:50 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 06 23:17:50 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2875 Bath and shower faucet, 2875:2875 Bath and shower faucet:315023
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 166 mm; NominalHeight: 85.4 mm; NominalWidth: 285 mm; Projection: 130 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2875; ConvergoRefNr: 0087-1809-0001-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 23/07/2018
Type - Green Building Properties(Type) - EAN Number: 6414150052569; EN Standard: EN 1111; ETA-Danmark: VA 1.43/17874; LVI Number: 6315610; Noise Class: II (ISO 3822); NRF Number: 4200635; RSK Number: 8613104; Sintef Certificate: Sintef Nr. 1324; STF Certificate: VTT-RTH-04949-08; VVS Number: 722252104
Type - Identity Data(Type) - Class: Thermostatic; Group: Bath and shower faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;RUS;SWE;UKR; Model: 2875 Bath and shower faucet; Name_en: 2875 Bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2875; Product Datasheet: https://www.oras.com/datasheet/2875/en; Product Family: Oras Cubista; Product URL: https://www.oras.com/en/products/oras/product/2875; Type Name: 2875 Bath and shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa: 0.0105944 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109791_PDM_943013_F_(943013-01-16).pdf; Installation Type: Wall-mounted; Installation Width: CC 150± 3 mm; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 175000 Pa; Pressure Loss With Flow 03ls: 290000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP2875/
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2875; Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2875; Name: 2875 Bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 285x166x85 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2875; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2875 Bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0878469 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00405377 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2875: 2875 Bath and shower faucet; Family and Type: 2875: 2875 Bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2875: 2875 Bath and shower faucet; Type Id: 2875: 2875 Bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
